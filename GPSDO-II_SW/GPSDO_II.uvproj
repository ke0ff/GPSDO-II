# Keil uVision project GPSDO_II.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F531 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(25000000)
  output: GPSDO2 +hex
  c flags: Optimize=2
  group Source Group 1
    ./: STARTUP.A51 main.c INIT.A51 serial.c f300_init.c flash.c nvmem.c
